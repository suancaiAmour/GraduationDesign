# Keil uVision project stm32test.uvprojx, settings and files
target APP (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32test +hex
  c flags: Optim=1
  c define: STM32F10X_HD USE_STDPERIPH_DRIVER
  c include: ..\cppfwlib;..\stm32stdlib\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\stm32stdlib\CMSIS\CM3\CoreSupport;..\stm32stdlib\STM32F10x_StdPeriph_Driver\inc;..\MMC_SD;..\FAT;..\LCD;..\main;..\sys;..\nstd
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group main
    ../main/: cpp_Test.cpp stm32f10x__tim.cpp stm32f10x__tim.h stm32f10x__spi.cpp allocator.cpp allocator.h template.cc
  group sys
    ../sys/: stm32f10x_conf.h stm32f10x_it.cpp stm32f10x_it.h SYS.cpp sys.h usart.cpp USART.H
  group nstd
    ../nstd/: BitOperation.h Debug.cpp debug.h define.h FIFO.h IOStream.cpp iostream.h nstd_assert.H nstd_static_assert.h nstd_type.cpp nstd_type.h Stack.h utilities.cpp utilities.h nstd_smart_pointer.h nstd_member_detector.h distributed_array.h
  group StartUp
    ../stm32stdlib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group cmsis
    ../stm32stdlib/CMSIS/CM3/CoreSupport/: core_cm3.c core_cm3.h
  group cppfwlib
    ../cppfwlib/: stm32f10x__AFIO.h stm32f10x__EXTI.h stm32f10x__FLASH.h stm32f10x__GPIO.h stm32f10x__GPIO_CPin.cpp stm32f10x__GPIO_CPin.h stm32f10x__IWDG.h stm32f10x__NVIC.cpp stm32f10x__NVIC.h stm32f10x__RCC.cpp stm32f10x__RCC.h stm32f10x__SCB.h stm32f10x__Systick.h stm32f10x__USART.cpp stm32f10x__USART.h stm32f10x__WWDG.h stm32f10x__cpplib.h stm32f10x__GPIO.cpp
  group stdperipLibSrc
    ../stm32stdlib/STM32F10x_StdPeriph_Driver/src/: stm32f10x_wwdg.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_sdio.c stm32f10x_rtc.c stm32f10x_rcc.c stm32f10x_pwr.c stm32f10x_iwdg.c stm32f10x_i2c.c stm32f10x_gpio.c stm32f10x_fsmc.c stm32f10x_flash.c stm32f10x_exti.c stm32f10x_dma.c stm32f10x_dbgmcu.c stm32f10x_dac.c stm32f10x_crc.c stm32f10x_cec.c stm32f10x_can.c stm32f10x_bkp.c stm32f10x_adc.c misc.c
  group stdPeriphLib
    ../stm32stdlib/: stm32f10x_stdPeriphLib_Release.lib
  group stdPeriphLibInc
    ../stm32stdlib/STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group fat32
    ../FAT/: FAT_FS.cpp FAT_FS.h FAT_Struct.h FileInfo.h
  group mmc_sd
    ../MMC_SD/: MMC_SD.cpp MMC_SD.H mmc_sd_old_functions.h
  group LCD
    ../LCD/: FONT.H ILI93xx.cpp LCD.h lcd_gui.cpp lcd_gui.h font.cpp
target createlib (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f10x_stdPeriphLib_Release +hex (library)
  c flags: Optim=4 oTime=1
  c define: STM32F10X_MD USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM;..\user;..\MYLIB;..\led;..\usart;..\EXTI;..\Libraries;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\SYSTEM\usart;..\Libraries\CMSIS\CM3\CoreSupport;..\myfwlib;..\FAT;..\SPI;..\MMC_SD;..\utilities;..\debug;..\Memory;..\stm32stdlib;..\stm32stdlib\CMSIS\CM3;..\stm32stdlib\STM32F10x_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --sort=calltree
--inline
software components: CMSIS:CORE 4.3.0

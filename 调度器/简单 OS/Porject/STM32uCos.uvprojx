# Keil uVision project STM32uCos.uvprojx, settings and files
target Stm32Switch (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: App +hex
  c flags: Optim=1
  c define: STM32F10X_HD
  c include: ..\Src\App\inc;..\Src\uCOS2\Core;..\Src\uCOS2\Ports;..\Src\Libraries\CMSIS\CM3\CoreSupport;..\Src\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Src\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Src\Switch
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Lib
    ../Src/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../Src/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../Src/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Src/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group Switch
    ../Src/Switch/: Switchc.c
  group App
    ../Src/App/src/: App.c
  group Doc
    ../Doc/: Readme.txt
software components: CMSIS:CORE 4.3.0
